# Keil uVision project GD32_F207_RT_Thread.uvprojx, settings and files
target GD32_F207 (ARM-ADS)
  device: GD32F207RG GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.1.0
  cpu: IROM(0x08000000,0x0100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32_F207_RT_Thread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\applications;..\Libraries\GD32F20x_standard_peripheral\Include;..\rtthread\kernel\include;..\..\GD32_F207_RT_Thread;..\Libraries\CMSIS\GD\GD32F20x\Include;..\Libraries;..\components\armlibc;..\components\armlibc\sys;..\components\finsh;..\components;..\components\drivers;..\components\rtc;..\components\dfs\include;..\components\fal-latest\inc;..\components\fal-latest\samples\porting;..\components\littlefs-v2.1.4
  asm include: ..\Libraries\GD32F20x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --keep __fsym_* --keep __vsym_*
  group Application
    ../applications/: startup.c threadlist.c
  group GD32_StdPeriph
    ../Libraries/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
    ../Libraries/: gd32f20x_it.c
    ../Libraries/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
    ../Libraries/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Kernel
    ../rtthread/kernel/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c udelay.c
    ../rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Drivers
    ../components/drivers/: serial.c usart.c mtd_nor.c sfud.c sfud_sfdp.c spi_core.c spi_dev.c spi_flash_sfud.c rt_gd32f20x_spi.c
    ../components/rtc/: ds1302z_rtc.c
  group Components
    ../components/armlibc/: libc_syms.c mem_std.c stubs.c
    ../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c completion.c dataqueue.c
  group FileSystem
    ../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../components/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../components/fal-latest/samples/porting/: fal_flash_sfud_port.c
    ../components/littlefs-v2.1.4/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
